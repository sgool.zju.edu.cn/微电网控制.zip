simulink model "combined061602_2018"  (R2018b)
settings: Solver=ode5  StartTime=0.0  StopTime=inf  FixedStep=1e-5  RelTol=1e-3
libraries: powerlib x156, powerlib_meascontrol x64, simulink x32, dspsigops x2
(part 4 of 5)

== system combined061602_2018/Subsystem/Storage Batteries3/变流器VF控制(电压环) ==
  Vd_Batt : Inport
  Vq_Batt : Inport  Port=2
  ILd : Inport  Port=3
  ILq : Inport  Port=4
  PQ2VF : Inport  Port=5
  Constant : Constant  Value=0.4/sqrt(3)*sqrt(2)
  Constant1 : Constant  Value=0
  Gain2 : Gain  Gain=100*pi*5500e-6
  Gain3 : Gain  Gain=100*pi*5500e-6
  PID Controller : simulink/Continuous/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=10  I=5000  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=rising  TrackingMode=off  Kt=1  LimitOutput=on  UpperSaturationLimit=1  LowerSaturationLimit=-1  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Enabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  PID Controller1 : simulink/Continuous/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=10  I=5000  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=rising  TrackingMode=off  Kt=1  LimitOutput=on  UpperSaturationLimit=1  LowerSaturationLimit=-1  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Enabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  PID Controller2 : simulink/Continuous/PID Controller  Commented=on  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=10  I=1/0.01  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=rising  TrackingMode=off  Kt=1  LimitOutput=off  UpperSaturationLimit=inf  LowerSaturationLimit=-inf  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Disabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  Scope{1..4} (4 alike) : Scope  NumInputPorts=2
  Scope5 : Scope  NumInputPorts=4
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=-+|
  Sum4 : Sum  Inputs=++-
  Sum5 : Sum  Inputs=+++
  Id_VFref : Outport
  Iq_VFref : Outport  Port=2
  wires:
  PQ2VF/1 -> PID Controller1/2, PID Controller/2
  Sum1/1 -> PID Controller1/1
  Sum/1 -> PID Controller/1
  Sum5/1 -> Iq_VFref/1, Scope5/4, Scope1/2
  Sum4/1 -> Id_VFref/1, Scope1/1
  ILq/1 -> Sum5/3, Scope5/3
  Constant1/1 -> [Vq_VFref]
  Gain2/1 -> Sum4/3
  Constant/1 -> [Vd_VFref]
  [Vq_VFref] -> Sum1/2, Scope4/2
  PID Controller/1 -> Sum4/2, Scope2/1
  Vq_Batt/1 -> Sum1/1, Gain2/1, Scope4/1
  ILd/1 -> Sum4/1
  [Vd_VFref] -> Sum/1, Scope3/1
  PID Controller1/1 -> Scope2/2, Sum5/2, Scope5/2
  Vd_Batt/1 -> Sum/2, Scope3/2, Gain3/1
  Gain3/1 -> Sum5/1, Scope5/1

== system combined061602_2018/Subsystem/Storage Batteries3/比例变换 ==
  proportion : Inport
  In1 : Inport  Port=2
  In2 : Inport  Port=3
  In3 : Inport  Port=4
  Product : Product
  Product1 : Product
  Product2 : Product
  Out1 : Outport
  Out2 : Outport  Port=2
  Out3 : Outport  Port=3
  wires:
  Product2/1 -> Out3/1
  In1/1 -> Product/1
  In2/1 -> Product1/1
  Product1/1 -> Out2/1
  Product/1 -> Out1/1
  In3/1 -> Product2/1
  proportion/1 -> Product/2, Product1/2, Product2/2

== system combined061602_2018/Subsystem/Storage Batteries3/电网电压定向，坐标变换 +瞬时功率计算 ==
  Uabc : Inport
  wt : Inport  Port=2
  ILabc : Inport  Port=3
  Add : Sum
  Add1 : Sum  Inputs=-+
  Demux : Demux  Outputs=3
  Demux2 : Demux  Outputs=3
  Gain : Gain  Gain=1.5
  Gain1 : Gain  Gain=1.5
  Mean : powerlib_meascontrol/Measurements/Mean  Freq=10  Vinit=0  Ts=0
  Mean1 : powerlib_meascontrol/Measurements/Mean  Freq=10  Vinit=0  Ts=0
  Product{,1..3} (4 alike) : Product
  Scope1 : Scope  NumInputPorts=2
  Scope2 : Scope  NumInputPorts=2
  Terminator : Terminator
  Terminator1 : Terminator
  abc to dq0_Current : powerlib_meascontrol/Transformations/abc to dq0  Alignment=90 degrees behind phase A axis
  abc to dq0_Voltage : powerlib_meascontrol/Transformations/abc to dq0  Alignment=90 degrees behind phase A axis
  Pinst : Outport
  Qinst : Outport  Port=2
  Ud : Outport  Port=3
  Uq : Outport  Port=4
  ILd : Outport  Port=5
  ILq : Outport  Port=6
  wires:
  Mean1/1 -> ILq/1, Scope2/1
  Mean/1 -> ILd/1, Scope1/1
  Demux/1 -> Product/1, Product2/1, Ud/1
  Add/1 -> Gain/1
  Add1/1 -> Gain1/1
  Gain1/1 -> Qinst/1
  Gain/1 -> Pinst/1
  Product2/1 -> Add1/1
  Demux/3 -> Terminator1/1
  Demux2/3 -> Terminator/1
  Product1/1 -> Add/2
  Product/1 -> Add/1
  Demux2/1 -> Product/2, Product3/2, Mean/1, Scope1/2
  Demux2/2 -> Product1/2, Product2/2, Mean1/1, Scope2/2
  Demux/2 -> Product3/1, Product1/1, Uq/1
  Product3/1 -> Add1/2
  Uabc/1 -> abc to dq0_Voltage/1
  wt/1 -> abc to dq0_Voltage/2, abc to dq0_Current/2
  ILabc/1 -> abc to dq0_Current/1
  abc to dq0_Current/1 -> Demux2/1
  abc to dq0_Voltage/1 -> Demux/1

== system combined061602_2018/Subsystem/Storage Batteries4/LC Filter reference ==
  Current Measurement : powerlib/Measurements/Current Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Current Measurement1 : powerlib/Measurements/Current Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Current Measurement2 : powerlib/Measurements/Current Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  LConnTagsString=a
  Ground1 : powerlib/Elements/Ground  LConnTagsString=a
  Ground2 : powerlib/Elements/Ground  LConnTagsString=a
  Mux : Mux  Inputs=3
  Mux1 : Mux  Inputs=3
  Series RLC Branch : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=1  Inductance=1.5e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch1 : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=5500e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch3 : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=1  Inductance=1.5e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch4 : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=5500e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch6 : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=1  Inductance=1.5e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch7 : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=5500e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Voltage Measurement1 : powerlib/Measurements/Voltage Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Voltage Measurement2 : powerlib/Measurements/Voltage Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Side=Left
  a : PMIOPort  Port=2  Side=Right
  B : PMIOPort  Port=3  Side=Left
  b : PMIOPort  Port=4  Side=Right
  C : PMIOPort  Port=5  Side=Left
  c : PMIOPort  Port=6  Side=Right
  Uabc : Outport
  ILabc : Outport  Port=2
  wires:
  Voltage Measurement2/1 -> Mux/2
  Voltage Measurement1/1 -> Mux/1
  Voltage Measurement/1 -> Mux/3
  Mux/1 -> Uabc/1
  Mux1/1 -> ILabc/1
  Current Measurement2/1 -> Mux1/1
  Current Measurement1/1 -> Mux1/2
  Current Measurement/1 -> Mux1/3
  connections:
  Series RLC Branch3/LConn1 -- B/RConn1
  Series RLC Branch6/LConn1 -- C/RConn1
  Series RLC Branch/LConn1 -- A/RConn1
  Ground1/LConn1 -- Voltage Measurement2/LConn2 -- Series RLC Branch4/RConn1
  Series RLC Branch6/RConn1 -- Current Measurement/LConn1 -- Voltage Measurement/LConn1 -- Series RLC Branch7/LConn1
  Ground2/LConn1 -- Voltage Measurement/LConn2 -- Series RLC Branch7/RConn1
  Ground/LConn1 -- Voltage Measurement1/LConn2 -- Series RLC Branch1/RConn1
  Series RLC Branch3/RConn1 -- Voltage Measurement2/LConn1 -- Current Measurement1/LConn1 -- Series RLC Branch4/LConn1
  Series RLC Branch/RConn1 -- Current Measurement2/LConn1 -- Voltage Measurement1/LConn1 -- Series RLC Branch1/LConn1
  Current Measurement1/RConn1 -- b/RConn1
  c/RConn1 -- Current Measurement/RConn1
  Current Measurement2/RConn1 -- a/RConn1

== system combined061602_2018/Subsystem/Storage Batteries4/LC Filter reference1 ==
  Current Measurement : powerlib/Measurements/Current Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Current Measurement1 : powerlib/Measurements/Current Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Current Measurement2 : powerlib/Measurements/Current Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  LConnTagsString=a
  Ground1 : powerlib/Elements/Ground  LConnTagsString=a
  Ground2 : powerlib/Elements/Ground  LConnTagsString=a
  Mux : Mux  Inputs=3
  Mux1 : Mux  Inputs=3
  Series RLC Branch : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=1  Inductance=0.2e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch1 : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=200e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch3 : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=1  Inductance=0.2e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch4 : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=200e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch6 : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=1  Inductance=0.2e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch7 : powerlib/Elements/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=200e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Voltage Measurement1 : powerlib/Measurements/Voltage Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Voltage Measurement2 : powerlib/Measurements/Voltage Measurement  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Side=Left
  a : PMIOPort  Port=2  Side=Right
  B : PMIOPort  Port=3  Side=Left
  b : PMIOPort  Port=4  Side=Right
  C : PMIOPort  Port=5  Side=Left
  c : PMIOPort  Port=6  Side=Right
  Uabc : Outport
  ILabc : Outport  Port=2
  wires:
  Voltage Measurement2/1 -> Mux/2
  Voltage Measurement1/1 -> Mux/1
  Voltage Measurement/1 -> Mux/3
  Mux/1 -> Uabc/1
  Mux1/1 -> ILabc/1
  Current Measurement2/1 -> Mux1/1
  Current Measurement1/1 -> Mux1/2
  Current Measurement/1 -> Mux1/3
  connections:
  Series RLC Branch3/LConn1 -- B/RConn1
  Series RLC Branch6/LConn1 -- C/RConn1
  Series RLC Branch/LConn1 -- A/RConn1
  Ground1/LConn1 -- Voltage Measurement2/LConn2 -- Series RLC Branch4/RConn1
  Series RLC Branch6/RConn1 -- Current Measurement/LConn1 -- Voltage Measurement/LConn1 -- Series RLC Branch7/LConn1
  Ground2/LConn1 -- Voltage Measurement/LConn2 -- Series RLC Branch7/RConn1
  Ground/LConn1 -- Voltage Measurement1/LConn2 -- Series RLC Branch1/RConn1
  Series RLC Branch3/RConn1 -- Voltage Measurement2/LConn1 -- Current Measurement1/LConn1 -- Series RLC Branch4/LConn1
  Series RLC Branch/RConn1 -- Current Measurement2/LConn1 -- Voltage Measurement1/LConn1 -- Series RLC Branch1/LConn1
  Current Measurement1/RConn1 -- b/RConn1
  c/RConn1 -- Current Measurement/RConn1
  Current Measurement2/RConn1 -- a/RConn1

== system combined061602_2018/Subsystem/Storage Batteries4/PLL ==
  Uabc : Inport
  Demux1 : Demux  Outputs=3
  PLL1 : powerlib_meascontrol/PLL/PLL  Fmin=45  Par_Init=[0, 50]  ParK=[180, 3200, 1]  TcD=1e-4  MaxRateChangeFreq=100  FilterCutOffFreq=25  Ts=0  AGC=on
  PLL_Parameter : powerlib_meascontrol/PLL/PLL  Fmin=45  Par_Init=[0, 50]  ParK=[50, 900, 0]  TcD=1e-4  MaxRateChangeFreq=12  FilterCutOffFreq=25  Ts=0  AGC=on
  Scope2 : Scope  NumInputPorts=2
  wt : Outport
  freq : Outport  Port=2
  wires:
  Uabc/1 -> Demux1/1
  Demux1/1 -> PLL1/1
  PLL1/2 -> Scope2/2, wt/1
  PLL1/1 -> Scope2/1, freq/1

== system combined061602_2018/Subsystem/Storage Batteries4/SPWM控制 ==
  a : Inport
  b : Inport  Port=2
  c : Inport  Port=3
  Logical Operator : Logic  Operator=NOT  AllPortsSameDT=off  OutDataTypeStr=boolean
  Logical Operator1 : Logic  Operator=NOT  AllPortsSameDT=off  OutDataTypeStr=boolean
  Logical Operator2 : Logic  Operator=NOT  AllPortsSameDT=off  OutDataTypeStr=boolean
  Mux1 : Mux  Inputs=6
  Relational Operator : RelationalOperator  OutDataTypeStr=boolean
  Relational Operator1 : RelationalOperator  OutDataTypeStr=boolean
  Relational Operator2 : RelationalOperator  OutDataTypeStr=boolean
  Triangle Generator : powerlib_meascontrol/Pulse & Signal Generators/Triangle Generator  Freq=5000  Phase=180  Ts=0
  g : Outport
  wires:
  Relational Operator1/1 -> Logical Operator1/1, Mux1/3
  Mux1/1 -> g/1
  Logical Operator/1 -> Mux1/2
  Relational Operator/1 -> Logical Operator/1, Mux1/1
  Triangle Generator/1 -> Relational Operator1/2, Relational Operator2/2, Relational Operator/2
  Relational Operator2/1 -> Mux1/5, Logical Operator2/1
  Logical Operator1/1 -> Mux1/4
  c/1 -> Relational Operator2/1
  Logical Operator2/1 -> Mux1/6
  b/1 -> Relational Operator1/1
  a/1 -> Relational Operator/1

== system combined061602_2018/Subsystem/Storage Batteries4/参考信号生成 ==
  Vd_ref : Inport
  Vq_ref : Inport  Port=2
  Vdc_Batt : Inport  Port=3
  Theta_Park : Inport  Port=4
  Constant : Constant  Value=0
  Constant1 : Constant  Value=350
  Demux1 : Demux  Outputs=3
  Divide : Product  Inputs=*/
  Divide1 : Product  Inputs=*/
  Gain : Gain  Gain=1/1000
  Gain6 : Gain  Gain=2
  Gain7 : Gain  Gain=2
  Mux : Mux  Inputs=3
  Switch1 : Switch  Criteria=u2 ~= 0
  dq0 to abc : powerlib_meascontrol/Transformations/dq0 to abc  Alignment=90 degrees behind phase A axis
  Ua_ref : Outport
  Ub_ref : Outport  Port=2
  Uc_ref : Outport  Port=3
  wires:
  Mux/1 -> dq0 to abc/1
  Divide1/1 -> Mux/2
  Vd_ref/1 -> Gain6/1
  Theta_Park/1 -> dq0 to abc/2
  Gain7/1 -> Divide1/1
  Vdc_Batt/1 -> Gain/1
  Gain6/1 -> Divide/1
  Divide/1 -> Mux/1
  Constant/1 -> Mux/3
  dq0 to abc/1 -> Demux1/1
  Demux1/2 -> Ub_ref/1
  Vq_ref/1 -> Gain7/1
  Demux1/3 -> Uc_ref/1
  Demux1/1 -> Ua_ref/1
  Gain/1 -> Switch1/1, Switch1/2
  Switch1/1 -> Divide/2, Divide1/2
  Constant1/1 -> Switch1/3

== system combined061602_2018/Subsystem/Storage Batteries4/变流器PQ-VF控制Iref切换 ==
  Id_PQref : Inport
  Iq_PQref : Inport  Port=2
  PQ2VF : Inport  Port=3
  Id_VFref : Inport  Port=4
  Iq_VFref : Inport  Port=5
  Saturation : Saturate  UpperLimit=5  LowerLimit=-5
  Saturation1 : Saturate  UpperLimit=5  LowerLimit=-5
  Switch : Switch  Criteria=u2 ~= 0
  Switch1 : Switch  Criteria=u2 ~= 0
  Idref : Outport
  Iqref : Outport  Port=2
  wires:
  PQ2VF/1 -> Switch1/2, Switch/2
  Switch1/1 -> Saturation1/1
  Switch/1 -> Saturation/1
  Id_PQref/1 -> Switch/3
  Id_VFref/1 -> Switch/1
  Iq_VFref/1 -> Switch1/1
  Iq_PQref/1 -> Switch1/3
  Saturation/1 -> Idref/1
  Saturation1/1 -> Iqref/1

== system combined061602_2018/Subsystem/Storage Batteries4/变流器PQ-VF控制theta变换 ==
  PQ2VF : Inport
  theta_PQref : Inport  Port=2
  Clock1 : Clock
  Constant3 : Constant  Value=2*pi
  Constant4 : Constant  Value=100*pi
  Constant5 : Constant  Value=0
  Mod : Math  Operator=mod
  Product1 : Product
  Sample and Hold : dspsigops/Sample and Hold  trig=Rising edge  initCond=0  latchinput=off
  Sum2 : Sum  Inputs=+|+
  Sum3 : Sum  Inputs=|+-
  Switch : Switch  Criteria=u2 ~= 0
  theta_Bat : Outport
  wires:
  Sum2/1 -> Mod/1
  Constant3/1 -> Mod/2
  PQ2VF/1 -> Switch/2, Sample and Hold/Trigger
  theta_PQref/1 -> Switch/3, Sample and Hold/1
  Switch/1 -> theta_Bat/1
  Mod/1 -> Switch/1
  Constant4/1 -> Product1/1
  Constant5/1 -> Sum3/2
  Sum3/1 -> Product1/2
  Clock1/1 -> Sum3/1
  Product1/1 -> Sum2/2
  Sample and Hold/1 -> Sum2/1

== system combined061602_2018/Subsystem/Storage Batteries4/变流器PQ控制(电压环) ==
  Pref : Inport
  Pinst : Inport  Port=2
  Qref : Inport  Port=3
  Qinst : Inport  Port=4
  PQ2VF : Inport  Port=5
  Discrete PID Controller : simulink/Continuous/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=0.02  I=1/1e-3  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=either  TrackingMode=off  Kt=1  LimitOutput=on  UpperSaturationLimit=13  LowerSaturationLimit=-13  LinearizeAsGain=off  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Enabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  Discrete PID Controller1 : simulink/Continuous/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=0.02  I=1/1e-3  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=either  TrackingMode=off  Kt=1  LimitOutput=on  UpperSaturationLimit=13  LowerSaturationLimit=-13  LinearizeAsGain=off  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Enabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  Gain : Gain  Gain=1e-6
  Gain2 : Gain  Gain=1e-6
  PID Controller : simulink/Continuous/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=10  I=1/1e-3  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=none  TrackingMode=off  Kt=1  LimitOutput=on  UpperSaturationLimit=13  LowerSaturationLimit=-13  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Enabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=Disabled  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  Saturation : Saturate  UpperLimit=5  LowerLimit=-5  LinearizeAsGain=off
  Saturation1 : Saturate  UpperLimit=5  LowerLimit=-5  LinearizeAsGain=off
  Scope1 : Scope  NumInputPorts=2
  Scope2 : Scope  NumInputPorts=2
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|-+
  Id_PQref : Outport
  Iq_PQref : Outport  Port=2
  wires:
  Saturation1/1 -> Scope1/2, Iq_PQref/1
  Saturation/1 -> Scope1/1, Id_PQref/1
  Discrete PID Controller1/1 -> Saturation1/1
  Sum1/1 -> Discrete PID Controller1/1
  Pref/1 -> Gain/1
  Gain/1 -> Sum/1
  Pinst/1 -> Sum/2
  Gain2/1 -> Scope2/1, Sum1/1
  Qref/1 -> Gain2/1
  Qinst/1 -> Scope2/2, Sum1/2
  Sum/1 -> Discrete PID Controller/1
  Discrete PID Controller/1 -> Saturation/1
  PQ2VF/1 -> Discrete PID Controller1/2, Discrete PID Controller/2

== system combined061602_2018/Subsystem/Storage Batteries4/变流器PQ控制(电流环) ==
  Vd_Batt : Inport
  Id_ref : Inport  Port=2
  Id_Batt : Inport  Port=3
  Iq_Batt : Inport  Port=4
  Iq_ref : Inport  Port=5
  Vq_Batt : Inport  Port=6
  Gain : Gain  Gain=100*pi*1.5e-3
  Gain1 : Gain  Gain=100*pi*1.5e-3
  PID Controller : simulink/Continuous/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=5  I=1/0.4  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=none  TrackingMode=off  Kt=1  LimitOutput=off  UpperSaturationLimit=inf  LowerSaturationLimit=-inf  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Disabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=Disabled  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  PID Controller1 : simulink/Continuous/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=5  I=1/0.4  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=none  TrackingMode=off  Kt=1  LimitOutput=off  UpperSaturationLimit=inf  LowerSaturationLimit=-inf  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Disabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=Disabled  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=-+|
  Sum4 : Sum  Inputs=++-
  Sum5 : Sum  Inputs=+++
  Vd_ref : Outport
  Vq_ref : Outport  Port=2
  wires:
  Iq_Batt/1 -> Gain/1, Sum1/1
  Vd_Batt/1 -> Sum4/1
  Id_Batt/1 -> Gain1/1, Sum/2
  Sum4/1 -> Vd_ref/1
  Sum5/1 -> Vq_ref/1
  PID Controller/1 -> Sum4/2
  Gain1/1 -> Sum5/1
  Gain/1 -> Sum4/3
  Vq_Batt/1 -> Sum5/3
  Iq_ref/1 -> Sum1/2
  Id_ref/1 -> Sum/1
  Sum/1 -> PID Controller/1
  PID Controller1/1 -> Sum5/2
  Sum1/1 -> PID Controller1/1

== system combined061602_2018/Subsystem/Storage Batteries4/变流器VF控制(电压环) ==
  Vd_Batt : Inport
  Vq_Batt : Inport  Port=2
  ILd : Inport  Port=3
  ILq : Inport  Port=4
  PQ2VF : Inport  Port=5
  Constant : Constant  Value=0.4/sqrt(3)*sqrt(2)
  Constant1 : Constant  Value=0
  Gain2 : Gain  Gain=100*pi*5500e-6
  Gain3 : Gain  Gain=100*pi*5500e-6
  PID Controller : simulink/Continuous/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=10  I=5000  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=rising  TrackingMode=off  Kt=1  LimitOutput=on  UpperSaturationLimit=1  LowerSaturationLimit=-1  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Enabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  PID Controller1 : simulink/Continuous/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=10  I=5000  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=rising  TrackingMode=off  Kt=1  LimitOutput=on  UpperSaturationLimit=1  LowerSaturationLimit=-1  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Enabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  PID Controller2 : simulink/Continuous/PID Controller  Commented=on  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=10  I=1/0.01  D=0  UseFilter=on  N=100  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=rising  TrackingMode=off  Kt=1  LimitOutput=off  UpperSaturationLimit=inf  LowerSaturationLimit=-inf  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Disabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI
  Scope{1..4} (4 alike) : Scope  NumInputPorts=2
  Scope5 : Scope  NumInputPorts=4
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=-+|
  Sum4 : Sum  Inputs=++-
  Sum5 : Sum  Inputs=+++
  Id_VFref : Outport
  Iq_VFref : Outport  Port=2
  wires:
  Gain3/1 -> Scope5/1, Sum5/1
  Vd_Batt/1 -> Gain3/1, Scope3/2, Sum/2
  PID Controller1/1 -> Scope5/2, Sum5/2, Scope2/2
  [Vd_VFref] -> Scope3/1, Sum/1
  ILd/1 -> Sum4/1
  Vq_Batt/1 -> Scope4/1, Gain2/1, Sum1/1
  PID Controller/1 -> Scope2/1, Sum4/2
  [Vq_VFref] -> Scope4/2, Sum1/2
  Constant/1 -> [Vd_VFref]
  Gain2/1 -> Sum4/3
  Constant1/1 -> [Vq_VFref]
  ILq/1 -> Scope5/3, Sum5/3
  Sum4/1 -> Scope1/1, Id_VFref/1
  Sum5/1 -> Scope1/2, Scope5/4, Iq_VFref/1
  Sum/1 -> PID Controller/1
  Sum1/1 -> PID Controller1/1
  PQ2VF/1 -> PID Controller/2, PID Controller1/2

== system combined061602_2018/Subsystem/Storage Batteries4/比例变换 ==
  proportion : Inport
  In1 : Inport  Port=2
  In2 : Inport  Port=3
  In3 : Inport  Port=4
  Product : Product
  Product1 : Product
  Product2 : Product
  Out1 : Outport
  Out2 : Outport  Port=2
  Out3 : Outport  Port=3
  wires:
  proportion/1 -> Product2/2, Product1/2, Product/2
  In3/1 -> Product2/1
  Product/1 -> Out1/1
  Product1/1 -> Out2/1
  In2/1 -> Product1/1
  In1/1 -> Product/1
  Product2/1 -> Out3/1

== system combined061602_2018/Subsystem/Storage Batteries4/电网电压定向，坐标变换 +瞬时功率计算 ==
  Uabc : Inport
  wt : Inport  Port=2
  ILabc : Inport  Port=3
  Add : Sum
  Add1 : Sum  Inputs=-+
  Demux : Demux  Outputs=3
  Demux2 : Demux  Outputs=3
  Gain : Gain  Gain=1.5
  Gain1 : Gain  Gain=1.5
  Mean : powerlib_meascontrol/Measurements/Mean  Freq=10  Vinit=0  Ts=0
  Mean1 : powerlib_meascontrol/Measurements/Mean  Freq=10  Vinit=0  Ts=0
  Product{,1..3} (4 alike) : Product
  Scope1 : Scope  NumInputPorts=2
  Scope2 : Scope  NumInputPorts=2
  Terminator : Terminator
  Terminator1 : Terminator
  abc to dq0_Current : powerlib_meascontrol/Transformations/abc to dq0  Alignment=90 degrees behind phase A axis
  abc to dq0_Voltage : powerlib_meascontrol/Transformations/abc to dq0  Alignment=90 degrees behind phase A axis
  Pinst : Outport
  Qinst : Outport  Port=2
  Ud : Outport  Port=3
  Uq : Outport  Port=4
  ILd : Outport  Port=5
  ILq : Outport  Port=6
  wires:
  abc to dq0_Voltage/1 -> Demux/1
  abc to dq0_Current/1 -> Demux2/1
  ILabc/1 -> abc to dq0_Current/1
  wt/1 -> abc to dq0_Current/2, abc to dq0_Voltage/2
  Uabc/1 -> abc to dq0_Voltage/1
  Product3/1 -> Add1/2
  Demux/2 -> Uq/1, Product1/1, Product3/1
  Demux2/2 -> Scope2/2, Mean1/1, Product2/2, Product1/2
  Demux2/1 -> Scope1/2, Mean/1, Product3/2, Product/2
  Product/1 -> Add/1
  Product1/1 -> Add/2
  Demux2/3 -> Terminator/1
  Demux/3 -> Terminator1/1
  Product2/1 -> Add1/1
  Gain/1 -> Pinst/1
  Gain1/1 -> Qinst/1
  Add1/1 -> Gain1/1
  Add/1 -> Gain/1
  Demux/1 -> Ud/1, Product2/1, Product/1
  Mean/1 -> Scope1/1, ILd/1
  Mean1/1 -> Scope2/1, ILq/1

== matlab function combined061602_2018/Subsystem/MT_1/MT Controller ==
function [ia,ib,ic] = fcn(Pref, Vref, theta, wt, active)

% 400V母线电压
U = Vref;
Qref = Pref*tan(theta);
% % 计算功率因数角 theta
% if Pref ~= 0
%     t_theta = Qref/Pref;
% else
%     t_theta = Qref/1e-3;
% end
% theta = atan(t_theta);

% 开路检测
if active == 1
    % 计算三相有功电流
    ia_p = Pref/3/U*sqrt(2)*sin(wt);
    ib_p = Pref/3/U*sqrt(2)*sin(wt - 2*pi/3);
    ic_p = Pref/3/U*sqrt(2)*sin(wt - 4*pi/3);
    % 计算三相无功电流
    ia_q = Qref/3/U*sqrt(2)*sin(wt - pi/2);
    ib_q = Qref/3/U*sqrt(2)*sin(wt - 2*pi/3 - pi/2);
    ic_q = Qref/3/U*sqrt(2)*sin(wt - 4*pi/3 - pi/2);
    % 三相电流合成
    ia = ia_p + ia_q;
    ib = ib_p + ib_q;
    ic = ic_p + ic_q;
else
    % 未合闸时，输出低电流，输出电压维持400V
    ia = 1e-6*400*sqrt(2)/26*sin(wt)*400*sqrt(2)/590.8*565.6854;
    ib = 1e-6*400*sqrt(2)/26*sin(wt - 2*pi/3)*400*sqrt(2)/590.8*565.6854;
    ic = 1e-6*400*sqrt(2)/26*sin(wt - 4*pi/3)*400*sqrt(2)/590.8*565.6854;
end

== matlab function combined061602_2018/Subsystem/Gen FSM ==
% function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,Param)
% 
% f = memory(1);
% T = memory(2);
% startEnable = memory(3);
% ratedSpeed = memory(4);
% Active = memory(5);
% 
% % Param = [4*60+50 5 90*60];
% if startEnable == 1 && StartCommand && f == 0
%     T = clock;
%     startEnable = 0;
%     f = 1;
% elseif clock - T >= Param(1) && f == 1
%     ratedSpeed = 1;
%     f = 2;
%     T = clock;
% elseif clock - T >= Param(2) && f == 2
%     Active = 1;
%     T = 0;
%     f = 3;
% elseif StartCommand == 0 && f == 3
%     T = clock;
%     ratedSpeed = 0;
%     f = 4;
%     Active = 0;
% elseif clock - T >= Param(3) && f == 4
%     startEnable = 1;
%     f = 0;
% end
% StartEnable = startEnable;
% RatedSpeed = ratedSpeed;
% memory = [f T startEnable ratedSpeed Active]';
% 
% end
function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,p,ClosegateCommand,OpengateCommand,stopcommand)

f = memory(1);
T = memory(2);
startEnable = memory(3);
ratedSpeed = memory(4);
Active = memory(5);

 Param = [0.2 0.3 0.1];

if startEnable == 1 && StartCommand && f == 0   %  燃机可启动 且 燃机开机指令置1 且 f==0，执行以下，可防止燃机重复开机
    T = clock;
    startEnable = 0;
    f = 1;
elseif clock - T >= Param(1) && f == 1    %   燃机在接受开机指令Param（1）时间后，燃机达到额定转速
    ratedSpeed = 1;
    f = 2;
    T = clock;
elseif ( ( clock - T >= Param(2) && f == 2 )||( f == 4 ) ) && ClosegateCommand ~= 0  % 在达到额定转速Param（2）时间后 && 有合闸指令，允许合闸（可以分配功率）
    Active = 1;
    T = 0;
    f = 3;
elseif OpengateCommand ~= 0 && f == 3 && p==0  % 当功率为0且有分闸指令时，允许分闸，不可分配功率
    T = clock;
    f = 4;
    Active = 0;
elseif f == 4 && stopcommand == 1  % 当有关机指令时，转速降为0
    T = clock;
    ratedSpeed = 0;
    f = 5;
elseif clock - T >= Param(3) && f == 5 %经过Param（3）时间后，关机完成，燃机可重新启动
    startEnable = 1;
    f = 0;
end
StartEnable = startEnable;
RatedSpeed = ratedSpeed;
memory = [f T startEnable ratedSpeed Active]';

end
