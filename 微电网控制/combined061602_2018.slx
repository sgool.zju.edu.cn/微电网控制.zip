simulink model "combined061602_2018"  (R2018b)
settings: Solver=ode5  StartTime=0.0  StopTime=inf  FixedStep=1e-5  RelTol=1e-3
libraries: powerlib x156, powerlib_meascontrol x64, simulink x32, dspsigops x2
(part 5 of 5)

== matlab function combined061602_2018/Subsystem/Gen FSM1 ==
% function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,Param)
% 
% f = memory(1);
% T = memory(2);
% startEnable = memory(3);
% ratedSpeed = memory(4);
% Active = memory(5);
% 
% % Param = [4*60+50 5 90*60];
% if startEnable == 1 && StartCommand && f == 0
%     T = clock;
%     startEnable = 0;
%     f = 1;
% elseif clock - T >= Param(1) && f == 1
%     ratedSpeed = 1;
%     f = 2;
%     T = clock;
% elseif clock - T >= Param(2) && f == 2
%     Active = 1;
%     T = 0;
%     f = 3;
% elseif StartCommand == 0 && f == 3
%     T = clock;
%     ratedSpeed = 0;
%     f = 4;
%     Active = 0;
% elseif clock - T >= Param(3) && f == 4
%     startEnable = 1;
%     f = 0;
% end
% StartEnable = startEnable;
% RatedSpeed = ratedSpeed;
% memory = [f T startEnable ratedSpeed Active]';
% 
% end
function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,p,ClosegateCommand,OpengateCommand,stopcommand)

f = memory(1);
T = memory(2);
startEnable = memory(3);
ratedSpeed = memory(4);
Active = memory(5);

 Param = [0.2 0.3 0.1];

if startEnable == 1 && StartCommand && f == 0   %  燃机可启动 且 燃机开机指令置1 且 f==0，执行以下，可防止燃机重复开机
    T = clock;
    startEnable = 0;
    f = 1;
elseif clock - T >= Param(1) && f == 1    %   燃机在接受开机指令Param（1）时间后，燃机达到额定转速
    ratedSpeed = 1;
    f = 2;
    T = clock;
elseif ( ( clock - T >= Param(2) && f == 2 )||( f == 4 ) ) && ClosegateCommand ~= 0  % 在达到额定转速Param（2）时间后 && 有合闸指令，允许合闸（可以分配功率）
    Active = 1;
    T = 0;
    f = 3;
elseif OpengateCommand ~= 0 && f == 3 && p==0  % 当功率为0且有分闸指令时，允许分闸，不可分配功率
    T = clock;
    f = 4;
    Active = 0;
elseif f == 4 && stopcommand == 1  % 当有关机指令时，转速降为0
    T = clock;
    ratedSpeed = 0;
    f = 5;
elseif clock - T >= Param(3) && f == 5 %经过Param（3）时间后，关机完成，燃机可重新启动
    startEnable = 1;
    f = 0;
end
StartEnable = startEnable;
RatedSpeed = ratedSpeed;
memory = [f T startEnable ratedSpeed Active]';

end

== matlab function combined061602_2018/Subsystem/Gen FSM2 ==
% function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,Param)
% 
% f = memory(1);
% T = memory(2);
% startEnable = memory(3);
% ratedSpeed = memory(4);
% Active = memory(5);
% 
% % Param = [4*60+50 5 90*60];
% if startEnable == 1 && StartCommand && f == 0
%     T = clock;
%     startEnable = 0;
%     f = 1;
% elseif clock - T >= Param(1) && f == 1
%     ratedSpeed = 1;
%     f = 2;
%     T = clock;
% elseif clock - T >= Param(2) && f == 2
%     Active = 1;
%     T = 0;
%     f = 3;
% elseif StartCommand == 0 && f == 3
%     T = clock;
%     ratedSpeed = 0;
%     f = 4;
%     Active = 0;
% elseif clock - T >= Param(3) && f == 4
%     startEnable = 1;
%     f = 0;
% end
% StartEnable = startEnable;
% RatedSpeed = ratedSpeed;
% memory = [f T startEnable ratedSpeed Active]';
% 
% end
function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,p,ClosegateCommand,OpengateCommand,stopcommand)

f = memory(1);
T = memory(2);
startEnable = memory(3);
ratedSpeed = memory(4);
Active = memory(5);

 Param = [0.2 0.3 0.1];

if startEnable == 1 && StartCommand && f == 0   %  燃机可启动 且 燃机开机指令置1 且 f==0，执行以下，可防止燃机重复开机
    T = clock;
    startEnable = 0;
    f = 1;
elseif clock - T >= Param(1) && f == 1    %   燃机在接受开机指令Param（1）时间后，燃机达到额定转速
    ratedSpeed = 1;
    f = 2;
    T = clock;
elseif ( ( clock - T >= Param(2) && f == 2 )||( f == 4 ) ) && ClosegateCommand ~= 0  % 在达到额定转速Param（2）时间后 && 有合闸指令，允许合闸（可以分配功率）
    Active = 1;
    T = 0;
    f = 3;
elseif OpengateCommand ~= 0 && f == 3 && p==0  % 当功率为0且有分闸指令时，允许分闸，不可分配功率
    T = clock;
    f = 4;
    Active = 0;
elseif f == 4 && stopcommand == 1  % 当有关机指令时，转速降为0
    T = clock;
    ratedSpeed = 0;
    f = 5;
elseif clock - T >= Param(3) && f == 5 %经过Param（3）时间后，关机完成，燃机可重新启动
    startEnable = 1;
    f = 0;
end
StartEnable = startEnable;
RatedSpeed = ratedSpeed;
memory = [f T startEnable ratedSpeed Active]';

end

== matlab function combined061602_2018/Subsystem/Gen FSM3 ==
% function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,Param)
% 
% f = memory(1);
% T = memory(2);
% startEnable = memory(3);
% ratedSpeed = memory(4);
% Active = memory(5);
% 
% % Param = [4*60+50 5 90*60];
% if startEnable == 1 && StartCommand && f == 0
%     T = clock;
%     startEnable = 0;
%     f = 1;
% elseif clock - T >= Param(1) && f == 1
%     ratedSpeed = 1;
%     f = 2;
%     T = clock;
% elseif clock - T >= Param(2) && f == 2
%     Active = 1;
%     T = 0;
%     f = 3;
% elseif StartCommand == 0 && f == 3
%     T = clock;
%     ratedSpeed = 0;
%     f = 4;
%     Active = 0;
% elseif clock - T >= Param(3) && f == 4
%     startEnable = 1;
%     f = 0;
% end
% StartEnable = startEnable;
% RatedSpeed = ratedSpeed;
% memory = [f T startEnable ratedSpeed Active]';
% 
% end
function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,p,ClosegateCommand,OpengateCommand,stopcommand)

f = memory(1);
T = memory(2);
startEnable = memory(3);
ratedSpeed = memory(4);
Active = memory(5);

 Param = [0.2 0.3 0.1];

if startEnable == 1 && StartCommand && f == 0   %  燃机可启动 且 燃机开机指令置1 且 f==0，执行以下，可防止燃机重复开机
    T = clock;
    startEnable = 0;
    f = 1;
elseif clock - T >= Param(1) && f == 1    %   燃机在接受开机指令Param（1）时间后，燃机达到额定转速
    ratedSpeed = 1;
    f = 2;
    T = clock;
elseif ( ( clock - T >= Param(2) && f == 2 )||( f == 4 ) ) && ClosegateCommand ~= 0   % 在达到额定转速Param（2）时间后 && 有合闸指令，允许合闸（可以分配功率）
    Active = 1;
    T = 0;
    f = 3;
elseif OpengateCommand ~= 0 && f == 3 && p==0  % 当功率为0且有分闸指令时，允许分闸，不可分配功率
    T = clock;
    f = 4;
    Active = 0;
elseif f == 4 && stopcommand == 1  % 当有关机指令时，转速降为0
    T = clock;
    ratedSpeed = 0;
    f = 5;
elseif clock - T >= Param(3) && f == 5 %经过Param（3）时间后，关机完成，燃机可重新启动
    startEnable = 1;
    f = 0;
end
StartEnable = startEnable;
RatedSpeed = ratedSpeed;
memory = [f T startEnable ratedSpeed Active]';

end

== matlab function combined061602_2018/Subsystem/Gen FSM4 ==
% function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,Param)
% 
% f = memory(1);
% T = memory(2);
% startEnable = memory(3);
% ratedSpeed = memory(4);
% Active = memory(5);
% 
% % Param = [4*60+50 5 90*60];
% if startEnable == 1 && StartCommand && f == 0
%     T = clock;
%     startEnable = 0;
%     f = 1;
% elseif clock - T >= Param(1) && f == 1
%     ratedSpeed = 1;
%     f = 2;
%     T = clock;
% elseif clock - T >= Param(2) && f == 2
%     Active = 1;
%     T = 0;
%     f = 3;
% elseif StartCommand == 0 && f == 3
%     T = clock;
%     ratedSpeed = 0;
%     f = 4;
%     Active = 0;
% elseif clock - T >= Param(3) && f == 4
%     startEnable = 1;
%     f = 0;
% end
% StartEnable = startEnable;
% RatedSpeed = ratedSpeed;
% memory = [f T startEnable ratedSpeed Active]';
% 
% end
function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,p,ClosegateCommand,OpengateCommand,stopcommand)

f = memory(1);
T = memory(2);
startEnable = memory(3);
ratedSpeed = memory(4);
Active = memory(5);
 Param = [0.2 0.3 0.1];

if startEnable == 1 && StartCommand && f == 0   %  燃机可启动 且 燃机开机指令置1 且 f==0，执行以下，可防止燃机重复开机
    T = clock;
    startEnable = 0;
    f = 1;
elseif clock - T >= Param(1) && f == 1    %   燃机在接受开机指令Param（1）时间后，燃机达到额定转速
    ratedSpeed = 1;
    f = 2;
    T = clock;
elseif ( ( clock - T >= Param(2) && f == 2 )||( f == 4 ) ) && ClosegateCommand ~= 0  % 在达到额定转速Param（2）时间后 && 有合闸指令，允许合闸（可以分配功率）
    Active = 1;
    T = 0;
    f = 3;
elseif OpengateCommand ~= 0 && f == 3 && p==0  % 当功率为0且有分闸指令时，允许分闸，不可分配功率
    T = clock;
    f = 4;
    Active = 0;
elseif f == 4 && stopcommand == 1  % 当有关机指令时，转速降为0
    T = clock;
    ratedSpeed = 0;
    f = 5;
elseif clock - T >= Param(3) && f == 5 %经过Param（3）时间后，关机完成，燃机可重新启动
    startEnable = 1;
    f = 0;
end
StartEnable = startEnable;
RatedSpeed = ratedSpeed;
memory = [f T startEnable ratedSpeed Active]';

end

== matlab function combined061602_2018/Subsystem/Gen FSM5 ==
% function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,Param)
% 
% f = memory(1);
% T = memory(2);
% startEnable = memory(3);
% ratedSpeed = memory(4);
% Active = memory(5);
% 
% % Param = [4*60+50 5 90*60];
% if startEnable == 1 && StartCommand && f == 0
%     T = clock;
%     startEnable = 0;
%     f = 1;
% elseif clock - T >= Param(1) && f == 1
%     ratedSpeed = 1;
%     f = 2;
%     T = clock;
% elseif clock - T >= Param(2) && f == 2
%     Active = 1;
%     T = 0;
%     f = 3;
% elseif StartCommand == 0 && f == 3
%     T = clock;
%     ratedSpeed = 0;
%     f = 4;
%     Active = 0;
% elseif clock - T >= Param(3) && f == 4
%     startEnable = 1;
%     f = 0;
% end
% StartEnable = startEnable;
% RatedSpeed = ratedSpeed;
% memory = [f T startEnable ratedSpeed Active]';
% 
% end
function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,p,ClosegateCommand,OpengateCommand,stopcommand)

f = memory(1);
T = memory(2);
startEnable = memory(3);
ratedSpeed = memory(4);
Active = memory(5);

 Param = [0.2 0.3 0.1];

if startEnable == 1 && StartCommand && f == 0   %  燃机可启动 且 燃机开机指令置1 且 f==0，执行以下，可防止燃机重复开机
    T = clock;
    startEnable = 0;
    f = 1;
elseif clock - T >= Param(1) && f == 1    %   燃机在接受开机指令Param（1）时间后，燃机达到额定转速
    ratedSpeed = 1;
    f = 2;
    T = clock;
elseif  ( ( clock - T >= Param(2) && f == 2 )||( f == 4 ) ) && ClosegateCommand ~= 0   % 在达到额定转速Param（2）时间后 && 有合闸指令，允许合闸（可以分配功率）
    Active = 1;
    T = 0;
    f = 3;
elseif OpengateCommand ~= 0 && f == 3 && p==0  % 当功率为0且有分闸指令时，允许分闸，不可分配功率
    T = clock;
    f = 4;
    Active = 0;
elseif f == 4 && stopcommand == 1  % 当有关机指令时，转速降为0
    T = clock;
    ratedSpeed = 0;
    f = 5;
elseif clock - T >= Param(3) && f == 5 %经过Param（3）时间后，关机完成，燃机可重新启动
    startEnable = 1;
    f = 0;
end
StartEnable = startEnable;
RatedSpeed = ratedSpeed;
memory = [f T startEnable ratedSpeed Active]';

end

== matlab function combined061602_2018/Subsystem/Gen FSM6 ==
% function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,Param)
% 
% f = memory(1);
% T = memory(2);
% startEnable = memory(3);
% ratedSpeed = memory(4);
% Active = memory(5);
% 
% % Param = [4*60+50 5 90*60];
% if startEnable == 1 && StartCommand && f == 0
%     T = clock;
%     startEnable = 0;
%     f = 1;
% elseif clock - T >= Param(1) && f == 1
%     ratedSpeed = 1;
%     f = 2;
%     T = clock;
% elseif clock - T >= Param(2) && f == 2
%     Active = 1;
%     T = 0;
%     f = 3;
% elseif StartCommand == 0 && f == 3
%     T = clock;
%     ratedSpeed = 0;
%     f = 4;
%     Active = 0;
% elseif clock - T >= Param(3) && f == 4
%     startEnable = 1;
%     f = 0;
% end
% StartEnable = startEnable;
% RatedSpeed = ratedSpeed;
% memory = [f T startEnable ratedSpeed Active]';
% 
% end
function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,p,ClosegateCommand,OpengateCommand,stopcommand)

f = memory(1);
T = memory(2);
startEnable = memory(3);
ratedSpeed = memory(4);
Active = memory(5);

 Param = [0.2 0.3 0.1];

if startEnable == 1 && StartCommand && f == 0   %  燃机可启动 且 燃机开机指令置1 且 f==0，执行以下，可防止燃机重复开机
    T = clock;
    startEnable = 0;
    f = 1;
elseif clock - T >= Param(1) && f == 1    %   燃机在接受开机指令Param（1）时间后，燃机达到额定转速
    ratedSpeed = 1;
    f = 2;
    T = clock;
elseif  ( ( clock - T >= Param(2) && f == 2 )||( f == 4 ) ) && ClosegateCommand ~= 0   % 在达到额定转速Param（2）时间后 && 有合闸指令，允许合闸（可以分配功率）
    Active = 1;
    T = 0;
    f = 3;
elseif OpengateCommand ~= 0 && f == 3 && p==0  % 当功率为0且有分闸指令时，允许分闸，不可分配功率
    T = clock;
    f = 4;
    Active = 0;
elseif f == 4 && stopcommand == 1  % 当有关机指令时，转速降为0
    T = clock;
    ratedSpeed = 0;
    f = 5;
elseif clock - T >= Param(3) && f == 5 %经过Param（3）时间后，关机完成，燃机可重新启动
    startEnable = 1;
    f = 0;
end
StartEnable = startEnable;
RatedSpeed = ratedSpeed;
memory = [f T startEnable ratedSpeed Active]';

end

== matlab function combined061602_2018/Subsystem/Load1/Current Caculator ==
function [ia, ib, ic] = fcn(p, q, wt, vrms, active)

% ph0 = wt;
% w = 2*pi*freq;
% t = clock;
if active >= 1
    %% 计算电流
    ia_p = -p/3/vrms*sqrt(2)*sin(wt);
    ib_p = -p/3/vrms*sqrt(2)*sin(wt - 2/3*pi);
    ic_p = -p/3/vrms*sqrt(2)*sin(wt - 4/3*pi);

    ia_q = -q/3/vrms*sqrt(2)*sin(wt - pi/2);
    ib_q = -q/3/vrms*sqrt(2)*sin(wt - 2/3*pi - pi/2);
    ic_q = -q/3/vrms*sqrt(2)*sin(wt - 4/3*pi - pi/2);

    ia = ia_p + ia_q;
    ib = ib_p + ib_q;
    ic = ic_p + ic_q;
else
    % 未合闸时，输出低电流，输出电压维持vrmsV
    ia = -1e-6*vrms*sqrt(2)/26*sin(wt)*vrms*sqrt(2)/590.8*565.6854;
    ib = -1e-6*vrms*sqrt(2)/26*sin(wt - 2*pi/3)*vrms*sqrt(2)/590.8*565.6854;
    ic = -1e-6*vrms*sqrt(2)/26*sin(wt - 4*pi/3)*vrms*sqrt(2)/590.8*565.6854;
end

== matlab function combined061602_2018/Subsystem/MATLAB Function1 ==
function [p,Tlast] = fcn(clock,plast,Tlast,Tchange)


if clock - Tlast > Tchange
Tlast = clock;
p = plast + 100e3 * sign(Tchange);
else
p = plast;
end

end

== matlab function combined061602_2018/Subsystem/Gen FSM7 ==
% function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,Param)
% 
% f = memory(1);
% T = memory(2);
% startEnable = memory(3);
% ratedSpeed = memory(4);
% Active = memory(5);
% 
% % Param = [4*60+50 5 90*60];
% if startEnable == 1 && StartCommand && f == 0
%     T = clock;
%     startEnable = 0;
%     f = 1;
% elseif clock - T >= Param(1) && f == 1
%     ratedSpeed = 1;
%     f = 2;
%     T = clock;
% elseif clock - T >= Param(2) && f == 2
%     Active = 1;
%     T = 0;
%     f = 3;
% elseif StartCommand == 0 && f == 3
%     T = clock;
%     ratedSpeed = 0;
%     f = 4;
%     Active = 0;
% elseif clock - T >= Param(3) && f == 4
%     startEnable = 1;
%     f = 0;
% end
% StartEnable = startEnable;
% RatedSpeed = ratedSpeed;
% memory = [f T startEnable ratedSpeed Active]';
% 
% end
function [StartEnable,RatedSpeed,Active,memory]  = fcn(StartCommand,clock,memory,p,ClosegateCommand,OpengateCommand,stopcommand)

f = memory(1);
T = memory(2);
startEnable = memory(3);
ratedSpeed = memory(4);
Active = memory(5);
 Param = [0.2 0.3 0.1];

if startEnable == 1 && StartCommand && f == 0   %  燃机可启动 且 燃机开机指令置1 且 f==0，执行以下，可防止燃机重复开机
    T = clock;
    startEnable = 0;
    f = 1;
elseif clock - T >= Param(1) && f == 1    %   燃机在接受开机指令Param（1）时间后，燃机达到额定转速
    ratedSpeed = 1;
    f = 2;
    T = clock;
elseif ( ( clock - T >= Param(2) && f == 2 )||( f == 4 ) ) && ClosegateCommand ~= 0  % 在达到额定转速Param（2）时间后 && 有合闸指令，允许合闸（可以分配功率）
    Active = 1;
    T = 0;
    f = 3;
elseif OpengateCommand ~= 0 && f == 3 && p==0  % 当功率为0且有分闸指令时，允许分闸，不可分配功率
    T = clock;
    f = 4;
    Active = 0;
elseif f == 4 && stopcommand == 1  % 当有关机指令时，转速降为0
    T = clock;
    ratedSpeed = 0;
    f = 5;
elseif clock - T >= Param(3) && f == 5 %经过Param（3）时间后，关机完成，燃机可重新启动
    startEnable = 1;
    f = 0;
end
StartEnable = startEnable;
RatedSpeed = ratedSpeed;
memory = [f T startEnable ratedSpeed Active]';

end

== matlab function combined061602_2018/Subsystem/MGCC1 ==
function [P1ref,theta1ref,enable1, v1ref, ... 
    P2ref,theta2ref,enable2, v2ref, ...
    P3ref,theta3ref,enable3, v3ref, ...
    P4ref,theta4ref,enable4, v4ref, ...
    P5ref,theta5ref,enable5, v5ref, ...
    P6ref,theta6ref,enable6, v6ref, ...
    P7ref,theta7ref,enable7, v7ref, ...
    P8ref,theta8ref,enable8, v8ref]  = fcn(clock, p_bat, p_load)

Vref = 400/sqrt(3);
%% 燃气轮机1控制逻辑
P1ref = 200e3;
theta1ref = 1*pi/180;
v1ref =Vref ;
if clock <= 5
    enable1 = 0;
else
    enable1 = 1;
end

%% 燃气轮机2控制逻辑
P2ref = 200e3 ;
theta2ref = 1*pi/180;
v2ref = Vref;
if clock <= 5
    enable2 =  0;
else
    enable2 = 1;
end

%% 燃气轮机3控制逻辑
P3ref = 200e3 ;
theta3ref = 1*pi/180;
v3ref = Vref;
if clock > 15
    enable2 = 0;
else
%     enable2 = 1;
end
enable3 = 0;
%% 燃气轮机4控制逻辑
P4ref = 100e3;
theta4ref = 1*pi/180;
v4ref = Vref;
if clock <= 40
    enable4 = 0;
else
    enable4 = 1;
end

%% 燃气轮机5控制逻辑
P5ref = 100e3;
theta5ref = 1*pi/180;
v5ref = Vref;
if clock <= 50
    enable5 = 0;
else
    enable5 = 1;
end

%% 燃气轮机6控制逻辑
P6ref = 100e3;
theta6ref = 1*pi/180;
v6ref = Vref;
if clock <= 60
    enable6 = 0;
else
    enable6 = 1;
end

%% 燃气轮机7控制逻辑
P7ref = 100e3;
theta7ref = 1*pi/180;
v7ref = Vref;
if clock <= 70
    enable7 = 0;
else
    enable7 = 1;
end

%% 燃气轮机8控制逻辑
P8ref = 100e3;
theta8ref = 1*pi/180;
v8ref = Vref;
if clock <= 80
    enable8 = 0;
else
    enable8 = 1;
end

if p_bat > 50e3
    P1ref = (p_bat - 50e3)/3 + P1ref;
    P2ref = (p_bat - 50e3)/3 + P2ref;
    P3ref = (p_bat - 50e3)/3 + P3ref;
end

== matlab function combined061602_2018/Subsystem/MT_10/MT Controller ==
function [ia,ib,ic] = fcn(Pref, Vref, theta, wt, active)

% 400V母线电压
U = Vref;
Qref = Pref*tan(theta);
% % 计算功率因数角 theta
% if Pref ~= 0
%     t_theta = Qref/Pref;
% else
%     t_theta = Qref/1e-3;
% end
% theta = atan(t_theta);

% 开路检测
if active == 1
    % 计算三相有功电流
    ia_p = Pref/3/U*sqrt(2)*sin(wt);
    ib_p = Pref/3/U*sqrt(2)*sin(wt - 2*pi/3);
    ic_p = Pref/3/U*sqrt(2)*sin(wt - 4*pi/3);
    % 计算三相无功电流
    ia_q = Qref/3/U*sqrt(2)*sin(wt - pi/2);
    ib_q = Qref/3/U*sqrt(2)*sin(wt - 2*pi/3 - pi/2);
    ic_q = Qref/3/U*sqrt(2)*sin(wt - 4*pi/3 - pi/2);
    % 三相电流合成
    ia = ia_p + ia_q;
    ib = ib_p + ib_q;
    ic = ic_p + ic_q;
else
    % 未合闸时，输出低电流，输出电压维持400V
    ia = 1e-6*400*sqrt(2)/26*sin(wt)*400*sqrt(2)/590.8*565.6854;
    ib = 1e-6*400*sqrt(2)/26*sin(wt - 2*pi/3)*400*sqrt(2)/590.8*565.6854;
    ic = 1e-6*400*sqrt(2)/26*sin(wt - 4*pi/3)*400*sqrt(2)/590.8*565.6854;
end

== matlab function combined061602_2018/Subsystem/MT_11/MT Controller ==
function [ia,ib,ic] = fcn(Pref, Vref, theta, wt, active)

% 400V母线电压
U = Vref;
Qref = Pref*tan(theta);
% % 计算功率因数角 theta
% if Pref ~= 0
%     t_theta = Qref/Pref;
% else
%     t_theta = Qref/1e-3;
% end
% theta = atan(t_theta);

% 开路检测
if active == 1
    % 计算三相有功电流
    ia_p = Pref/3/U*sqrt(2)*sin(wt);
    ib_p = Pref/3/U*sqrt(2)*sin(wt - 2*pi/3);
    ic_p = Pref/3/U*sqrt(2)*sin(wt - 4*pi/3);
    % 计算三相无功电流
    ia_q = Qref/3/U*sqrt(2)*sin(wt - pi/2);
    ib_q = Qref/3/U*sqrt(2)*sin(wt - 2*pi/3 - pi/2);
    ic_q = Qref/3/U*sqrt(2)*sin(wt - 4*pi/3 - pi/2);
    % 三相电流合成
    ia = ia_p + ia_q;
    ib = ib_p + ib_q;
    ic = ic_p + ic_q;
else
    % 未合闸时，输出低电流，输出电压维持400V
    ia = 1e-6*400*sqrt(2)/26*sin(wt)*400*sqrt(2)/590.8*565.6854;
    ib = 1e-6*400*sqrt(2)/26*sin(wt - 2*pi/3)*400*sqrt(2)/590.8*565.6854;
    ic = 1e-6*400*sqrt(2)/26*sin(wt - 4*pi/3)*400*sqrt(2)/590.8*565.6854;
end

== matlab function combined061602_2018/Subsystem/MT_12/MT Controller ==
function [ia,ib,ic] = fcn(Pref, Vref, theta, wt, active)

% 400V母线电压
U = Vref;
Qref = Pref*tan(theta);
% % 计算功率因数角 theta
% if Pref ~= 0
%     t_theta = Qref/Pref;
% else
%     t_theta = Qref/1e-3;
% end
% theta = atan(t_theta);

% 开路检测
if active == 1
    % 计算三相有功电流
    ia_p = Pref/3/U*sqrt(2)*sin(wt);
    ib_p = Pref/3/U*sqrt(2)*sin(wt - 2*pi/3);
    ic_p = Pref/3/U*sqrt(2)*sin(wt - 4*pi/3);
    % 计算三相无功电流
    ia_q = Qref/3/U*sqrt(2)*sin(wt - pi/2);
    ib_q = Qref/3/U*sqrt(2)*sin(wt - 2*pi/3 - pi/2);
    ic_q = Qref/3/U*sqrt(2)*sin(wt - 4*pi/3 - pi/2);
    % 三相电流合成
    ia = ia_p + ia_q;
    ib = ib_p + ib_q;
    ic = ic_p + ic_q;
else
    % 未合闸时，输出低电流，输出电压维持400V
    ia = 1e-6*400*sqrt(2)/26*sin(wt)*400*sqrt(2)/590.8*565.6854;
    ib = 1e-6*400*sqrt(2)/26*sin(wt - 2*pi/3)*400*sqrt(2)/590.8*565.6854;
    ic = 1e-6*400*sqrt(2)/26*sin(wt - 4*pi/3)*400*sqrt(2)/590.8*565.6854;
end

== matlab function combined061602_2018/Subsystem/MT_13/MT Controller ==
function [ia,ib,ic] = fcn(Pref, Vref, theta, wt, active)

% 400V母线电压
U = Vref;
Qref = Pref*tan(theta);
% % 计算功率因数角 theta
% if Pref ~= 0
%     t_theta = Qref/Pref;
% else
%     t_theta = Qref/1e-3;
% end
% theta = atan(t_theta);

% 开路检测
if active == 1
    % 计算三相有功电流
    ia_p = Pref/3/U*sqrt(2)*sin(wt);
    ib_p = Pref/3/U*sqrt(2)*sin(wt - 2*pi/3);
    ic_p = Pref/3/U*sqrt(2)*sin(wt - 4*pi/3);
    % 计算三相无功电流
    ia_q = Qref/3/U*sqrt(2)*sin(wt - pi/2);
    ib_q = Qref/3/U*sqrt(2)*sin(wt - 2*pi/3 - pi/2);
    ic_q = Qref/3/U*sqrt(2)*sin(wt - 4*pi/3 - pi/2);
    % 三相电流合成
    ia = ia_p + ia_q;
    ib = ib_p + ib_q;
    ic = ic_p + ic_q;
else
    % 未合闸时，输出低电流，输出电压维持400V
    ia = 1e-6*400*sqrt(2)/26*sin(wt)*400*sqrt(2)/590.8*565.6854;
    ib = 1e-6*400*sqrt(2)/26*sin(wt - 2*pi/3)*400*sqrt(2)/590.8*565.6854;
    ic = 1e-6*400*sqrt(2)/26*sin(wt - 4*pi/3)*400*sqrt(2)/590.8*565.6854;
end

== matlab function combined061602_2018/Subsystem/MT_14/MT Controller ==
function [ia,ib,ic] = fcn(Pref, Vref, theta, wt, active)

% 400V母线电压
U = Vref;
Qref = Pref*tan(theta);
% % 计算功率因数角 theta
% if Pref ~= 0
%     t_theta = Qref/Pref;
% else
%     t_theta = Qref/1e-3;
% end
% theta = atan(t_theta);

% 开路检测
if active == 1
    % 计算三相有功电流
    ia_p = Pref/3/U*sqrt(2)*sin(wt);
    ib_p = Pref/3/U*sqrt(2)*sin(wt - 2*pi/3);
    ic_p = Pref/3/U*sqrt(2)*sin(wt - 4*pi/3);
    % 计算三相无功电流
    ia_q = Qref/3/U*sqrt(2)*sin(wt - pi/2);
    ib_q = Qref/3/U*sqrt(2)*sin(wt - 2*pi/3 - pi/2);
    ic_q = Qref/3/U*sqrt(2)*sin(wt - 4*pi/3 - pi/2);
    % 三相电流合成
    ia = ia_p + ia_q;
    ib = ib_p + ib_q;
    ic = ic_p + ic_q;
else
    % 未合闸时，输出低电流，输出电压维持400V
    ia = 1e-6*400*sqrt(2)/26*sin(wt)*400*sqrt(2)/590.8*565.6854;
    ib = 1e-6*400*sqrt(2)/26*sin(wt - 2*pi/3)*400*sqrt(2)/590.8*565.6854;
    ic = 1e-6*400*sqrt(2)/26*sin(wt - 4*pi/3)*400*sqrt(2)/590.8*565.6854;
end

== matlab function combined061602_2018/Subsystem/MT_15/MT Controller ==
function [ia,ib,ic] = fcn(Pref, Vref, theta, wt, active)

% 400V母线电压
U = Vref;
Qref = Pref*tan(theta);
% % 计算功率因数角 theta
% if Pref ~= 0
%     t_theta = Qref/Pref;
% else
%     t_theta = Qref/1e-3;
% end
% theta = atan(t_theta);

% 开路检测
if active == 1
    % 计算三相有功电流
    ia_p = Pref/3/U*sqrt(2)*sin(wt);
    ib_p = Pref/3/U*sqrt(2)*sin(wt - 2*pi/3);
    ic_p = Pref/3/U*sqrt(2)*sin(wt - 4*pi/3);
    % 计算三相无功电流
    ia_q = Qref/3/U*sqrt(2)*sin(wt - pi/2);
    ib_q = Qref/3/U*sqrt(2)*sin(wt - 2*pi/3 - pi/2);
    ic_q = Qref/3/U*sqrt(2)*sin(wt - 4*pi/3 - pi/2);
    % 三相电流合成
    ia = ia_p + ia_q;
    ib = ib_p + ib_q;
    ic = ic_p + ic_q;
else
    % 未合闸时，输出低电流，输出电压维持400V
    ia = 1e-6*400*sqrt(2)/26*sin(wt)*400*sqrt(2)/590.8*565.6854;
    ib = 1e-6*400*sqrt(2)/26*sin(wt - 2*pi/3)*400*sqrt(2)/590.8*565.6854;
    ic = 1e-6*400*sqrt(2)/26*sin(wt - 4*pi/3)*400*sqrt(2)/590.8*565.6854;
end

== matlab function combined061602_2018/Subsystem/MT_9/MT Controller ==
function [ia,ib, ic] = fcn(Pref, Vref, theta, wt, active)

% 400V母线电压
U = Vref;
Qref = Pref*tan(theta);
% % 计算功率因数角 theta
% if Pref ~= 0
%     t_theta = Qref/Pref;
% else
%     t_theta = Qref/1e-3;
% end
% theta = atan(t_theta);

% 开路检测
if active == 1
    % 计算三相有功电流
    ia_p = Pref/3/U*sqrt(2)*sin(wt);
    ib_p = Pref/3/U*sqrt(2)*sin(wt - 2*pi/3);
    ic_p = Pref/3/U*sqrt(2)*sin(wt - 4*pi/3);
    % 计算三相无功电流
    ia_q = Qref/3/U*sqrt(2)*sin(wt - pi/2);
    ib_q = Qref/3/U*sqrt(2)*sin(wt - 2*pi/3 - pi/2);
    ic_q = Qref/3/U*sqrt(2)*sin(wt - 4*pi/3 - pi/2);
    % 三相电流合成
    ia = ia_p + ia_q;
    ib = ib_p + ib_q;
    ic = ic_p + ic_q;
else
    % 未合闸时，输出低电流，输出电压维持400V
    ia = 1e-6*400*sqrt(2)/26*sin(wt)*400*sqrt(2)/590.8*565.6854;
    ib = 1e-6*400*sqrt(2)/26*sin(wt - 2*pi/3)*400*sqrt(2)/590.8*565.6854;
    ic = 1e-6*400*sqrt(2)/26*sin(wt - 4*pi/3)*400*sqrt(2)/590.8*565.6854;
end
